# Keil uVision project third.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: third
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\ucos2\Cfg\Template;.\ucos2\Ports;.\ucos2\Source;.\App;..\5_to_stm32;.\ucos2\Cfg;.\App\hardware;.\SystemView\GenericConfig;.\SystemView\GenericFiles;.\SystemView\OSSpecific
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Cfg
    ./ucos2/Cfg/Template/: app_cfg.h app_hooks.c os_cfg.h
    ./ucos2/Cfg/: includes.h
  group Source
    ./ucos2/Source/: os.h os_core.c os_dbg_r.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c os_trace.h ucos_ii.c ucos_ii.h
  group Ports
    ./ucos2/Ports/: os_cpu_c.c os_cpu.h os_cpu_a.s
  group App
    ./App/: main.c systick.c
  group Start
    ./Start/: startup.s system.c my_start.s clock_cfg.c my_system.c
  group Hardware
    ./App/hardware/: led.c led.h
  group SystemView
    ./SystemView/OSSpecific/: os_cfg_trace.h os_trace_events.h SEGGER_SYSVIEW_Config_uCOSII.c SEGGER_SYSVIEW_uCOSII.c
    ./SystemView/GenericFiles/: SEGGER.h SEGGER_RTT.c SEGGER_RTT.h SEGGER_SYSVIEW.c SEGGER_SYSVIEW.h SEGGER_SYSVIEW_Int.h SEGGER_SYSVIEW_ConfDefaults.h
    ./SystemView/GenericConfig/: Global.h SEGGER_RTT_Conf.h SEGGER_SYSVIEW_Conf.h
software components: CMSIS:CORE 5.5.0
